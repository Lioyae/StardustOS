# Keil uVision project stc32g.uvprojx, settings and files
target STC32G (MCS-251)
  device: 8xC251SB Intel
  cpu: IRAM(0 - 0x41F) CLOCK(24000000) IROM(0xFF0000-0xFF3FFF)
  output: stc32g +hex
  asm misc: FIXDRK REGISTERBANK (0)
  group StardustOS
    ../../stardustos/: star.c star_task.c star_mail.c
    ../../stardustos/port/: star_port.c
  group User
    ./: main.c
