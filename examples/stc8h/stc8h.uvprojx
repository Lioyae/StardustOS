# Keil uVision project stc8h.uvprojx, settings and files
target STC8H (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: stc8h +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STAR_RAM_XDATA=1
  c include: ..\..\stardustos;..\..\stardustos\port\8051;.\
  group StardustOS
    ../../stardustos/: star.c star_task.c star_mail.c
    ../../stardustos/port/: star_port.c
  group User
    ./: main.c
