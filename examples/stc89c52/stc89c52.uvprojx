# Keil uVision project stc89c52.uvprojx, settings and files
target STC89C52 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: stc89c52 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STAR_RAM_XDATA=1, STAR_PORT_NO_TICK_ISR
  c include: ..\..\stardustos;..\..\stardustos\port\8051
  group StardustOS
    ../../stardustos/: star.c star_task.c star_mail.c
    ../../stardustos/port/: star_port.c
  group User
    ./: main.c STARTUP.A51
